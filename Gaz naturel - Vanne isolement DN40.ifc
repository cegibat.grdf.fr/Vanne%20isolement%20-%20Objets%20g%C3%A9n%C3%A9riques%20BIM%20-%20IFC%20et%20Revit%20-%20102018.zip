Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:05:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:05:22 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{5960722D-8F3C-406C-A758-3B4E50645DF0}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:05:20 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:05:21 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:05:21 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: DN 40, Gaz naturel – Vanne isolement:DN 40:207267
In: Niveau 1
Type - Material: Métal corps, Jaune Manche
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Vanne isolement
Type - Données d'identification(Type) - Nom du type: DN 40
Pset_DistributionFlowElementCommon - Reference: DN 40
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Vanne isolement: DN 40; Famille et type: Gaz naturel – Vanne isolement: DN 40; ID du type: Gaz naturel – Vanne isolement: DN 40; Type: Gaz naturel – Vanne isolement: DN 40
Contraintes - A Longueur: 104 mm; B Hauteur: 70 mm; C Longueur poignée: 138 mm; Décalage: 0 mm; DN: 40 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Matériau corps: Métal corps; Matériau poignée: Jaune Manche; Niveau: Niveau: Niveau 1; Pression max: 0 Pa; Température max: 0 kg/K/s3; Température min: 0 kg/K/s3
Cotes - C1.3: 46 mm; C30: 4.6 mm; C-30-2: 2.3 mm; C30-4: 1.15 mm; DIAM_INT_PROP_FORME_2: 8.4 mm; DIN_INT_3_2: 6.66667 mm; DN_BLOC: 40 mm; DN_EXT: 60 mm; DN_INT_2: 20 mm; DN_INT_2_3: 6.66667 mm; DN_INT_3: 13.3333 mm; FORME_1_PROP_A: 20.8 mm; FORME_2_PROP_DN_INT: 28 mm; FORME_3_LARGE_PROP: 9.33333 mm; H: 55 mm; H-4: 13.75 mm; PROP_Dn1+15: 19 mm; Surface: 0.0321039 m2; Taille: 40 mmø-40 mmø; Taille maximale: 40 mm; Taille minimale: 40 mm; Volume: 0.000301741 m3
Données d'identification - Identifiant: 20
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 40 mmø-40 mmø
Phase de construction - Phase de création: Nouvelle construction
