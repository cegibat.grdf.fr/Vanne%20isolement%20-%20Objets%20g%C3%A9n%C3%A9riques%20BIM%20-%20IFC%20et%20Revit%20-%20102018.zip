Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:03:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:03:48 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{822EB95E-9705-4B12-BF88-7334B638F945}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:03:46 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:03:46 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:03:46 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: DN 15, Gaz naturel – Vanne isolement:DN 15:207179
In: Niveau 1
Type - Material: Métal corps, Jaune Manche
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Vanne isolement
Type - Données d'identification(Type) - Nom du type: DN 15
Pset_DistributionFlowElementCommon - Reference: DN 15
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Vanne isolement: DN 15; Famille et type: Gaz naturel – Vanne isolement: DN 15; ID du type: Gaz naturel – Vanne isolement: DN 15; Type: Gaz naturel – Vanne isolement: DN 15
Contraintes - A Longueur: 60 mm; B Hauteur: 37 mm; C Longueur poignée: 78 mm; Décalage: 0 mm; DN: 15 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Matériau corps: Métal corps; Matériau poignée: Jaune Manche; Niveau: Niveau: Niveau 1; Pression max: 0 Pa; Température max: 0 kg/K/s3; Température min: 0 kg/K/s3
Cotes - C1.3: 26 mm; C30: 2.6 mm; C-30-2: 1.3 mm; C30-4: 0.65 mm; DIAM_INT_PROP_FORME_2: 3.15 mm; DIN_INT_3_2: 2.5 mm; DN_BLOC: 15 mm; DN_EXT: 22.5 mm; DN_INT_2: 7.5 mm; DN_INT_2_3: 2.5 mm; DN_INT_3: 5 mm; FORME_1_PROP_A: 12 mm; FORME_2_PROP_DN_INT: 10.5 mm; FORME_3_LARGE_PROP: 3.5 mm; H: 26 mm; H-4: 6.5 mm; PROP_Dn1+15: 10.25 mm; Surface: 0.0071689 m2; Taille: 15 mmø-15 mmø; Taille maximale: 15 mm; Taille minimale: 15 mm; Volume: 0.0000280523 m3
Données d'identification - Identifiant: 16
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 15 mmø-15 mmø
Phase de construction - Phase de création: Nouvelle construction
