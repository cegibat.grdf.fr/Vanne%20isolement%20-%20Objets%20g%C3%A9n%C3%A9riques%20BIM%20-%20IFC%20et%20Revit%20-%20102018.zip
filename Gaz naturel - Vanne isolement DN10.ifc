Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:03:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:03:24 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{A6F8C729-74D4-48E4-85DF-7EAC9287FB06}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:03:22 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:03:23 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:03:23 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: DN 10, Gaz naturel – Vanne isolement:DN 10:207157
In: Niveau 1
Type - Material: Métal corps, Jaune Manche
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Vanne isolement
Type - Données d'identification(Type) - Nom du type: DN 10
Pset_DistributionFlowElementCommon - Reference: DN 10
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Vanne isolement: DN 10; Famille et type: Gaz naturel – Vanne isolement: DN 10; ID du type: Gaz naturel – Vanne isolement: DN 10; Type: Gaz naturel – Vanne isolement: DN 10
Contraintes - A Longueur: 49 mm; B Hauteur: 34 mm; C Longueur poignée: 78 mm; Décalage: 0 mm; DN: 10 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Matériau corps: Métal corps; Matériau poignée: Jaune Manche; Niveau: Niveau: Niveau 1; Pression max: 0 Pa; Température max: 0 kg/K/s3; Température min: 0 kg/K/s3
Cotes - C1.3: 26 mm; C30: 2.6 mm; C-30-2: 1.3 mm; C30-4: 0.65 mm; DIAM_INT_PROP_FORME_2: 2.1 mm; DIN_INT_3_2: 1.66667 mm; DN_BLOC: 10 mm; DN_EXT: 15 mm; DN_INT_2: 5 mm; DN_INT_2_3: 1.66667 mm; DN_INT_3: 3.33333 mm; FORME_1_PROP_A: 9.8 mm; FORME_2_PROP_DN_INT: 7 mm; FORME_3_LARGE_PROP: 2.33333 mm; H: 21 mm; H-4: 5.25 mm; PROP_Dn1+15: 8.5 mm; Surface: 0.004252 m2; Taille: 10 mmø-10 mmø; Taille maximale: 10 mm; Taille minimale: 10 mm; Volume: 0.0000118126 m3
Données d'identification - Identifiant: 15
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 10 mmø-10 mmø
Phase de construction - Phase de création: Nouvelle construction
